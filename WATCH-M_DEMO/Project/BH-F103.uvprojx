# Keil uVision project BH-F103.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BH-F103 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\bsp_KEY;..\User\bsp_USART;..\User\bsp_TIME;..\User\MY_List;..\User\bsp_FONT;..\User\bsp_RTC;..\User\bsp_MPU6050;..\User\bsp_Beeper;..\User\MY_MUNE;..\User\bsp_OLED;..\User\MY_APP;..\User\bsp_GPIO;..\User\bsp_power;..\User\GAME
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c stm32f10x_conf.h
  group DOC
    ./: readme.txt
  group HARDWARE
    ../User/bsp_KEY/: bsp_key.c
    ../User/bsp_MPU6050/: bsp_mpu6050.c
    ../User/bsp_RTC/: bsp_rtc.c
    ../User/bsp_TIME/: bsp_time.c
    ../User/bsp_USART/: bsp_usart.c
    ../User/led/: bsp_led.c
    ../User/bsp_Beeper/: bsp_Beeper.c
    ../User/bsp_power/: bsp_power.c
  group SOFTWARE
    ../User/bsp_FONT/: bsp_Font.c
    ../User/bsp_OLED/: bsp_oled.c
  group MUNE
    ../User/MY_MUNE/: my_mune.c
    ../User/MY_List/: my_List.c
  group GAME
    ../User/GAME/: game1.c game2.c
  group APP
    ../User/MY_APP/: my_sec_tick.c my_edition.c
